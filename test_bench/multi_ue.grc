<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>zeromq_rep_sink</key>
<param><key>id</key><value>zeromq_rep_sink_0</value></param>
<param><key>address</key><value>tcp://*:2100</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_rep_sink</key>
<param><key>id</key><value>zeromq_rep_sink_1</value></param>
<param><key>address</key><value>tcp://*:2010</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_rep_sink</key>
<param><key>id</key><value>zeromq_rep_sink_2</value></param>
<param><key>address</key><value>tcp://*:2000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_req_source</key>
<param><key>id</key><value>zeromq_req_source_0</value></param>
<param><key>address</key><value>tcp://localhost:2011</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_req_source</key>
<param><key>id</key><value>zeromq_req_source_1</value></param>
<param><key>address</key><value>tcp://localhost:2001</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_req_source</key>
<param><key>id</key><value>zeromq_req_source_3</value></param>
<param><key>address</key><value>tcp://localhost:2101</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>zeromq_rep_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_req_source_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>zeromq_req_source_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_req_source_3</source_block_id><sink_block_id>zeromq_rep_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_req_source_3</source_block_id><sink_block_id>zeromq_rep_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
